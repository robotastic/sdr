<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>hackrf=0</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>858e6</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>0</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>14</value></param>
<param><key>if_gain0</key><value>25</value></param>
<param><key>bb_gain0</key><value>25</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dst_addr</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dst_port</value></param>
<param><key>value</key><value>8080</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>dst_port</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>samp_rate/100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_tap</value></param>
<param><key>value</key><value>firdes.low_pass(1,samp_rate, 25000,10000, firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_3</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>firdes_tap</value></param>
<param><key>center_freq</key><value>-3000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>dst_addr</value></param>
<param><key>port</key><value>dst_port</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>(samp_rate/decim)/15000</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decim</value></param>
<param><key>cutoff_freq</key><value>7000</value></param>
<param><key>width</key><value>6000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>firdes_tap</value></param>
<param><key>center_freq</key><value>3000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>(samp_rate/decim)/15000</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decim</value></param>
<param><key>cutoff_freq</key><value>7000</value></param>
<param><key>width</key><value>6000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value></value></param>
<param><key>port</key><value>dst_port+3</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>firdes_tap</value></param>
<param><key>center_freq</key><value>2000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>(samp_rate/decim)/15000</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decim</value></param>
<param><key>cutoff_freq</key><value>7000</value></param>
<param><key>width</key><value>6000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value></value></param>
<param><key>port</key><value>dst_port+2</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value></value></param>
<param><key>port</key><value>dst_port+1</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>firdes_tap</value></param>
<param><key>center_freq</key><value>-2000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>(samp_rate/decim)/15000</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decim</value></param>
<param><key>cutoff_freq</key><value>7000</value></param>
<param><key>width</key><value>6000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>15000</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_3</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_udp_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_2</source_block_id><sink_block_id>low_pass_filter_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_2</source_block_id><sink_block_id>blocks_udp_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1</source_block_id><sink_block_id>low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_udp_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
